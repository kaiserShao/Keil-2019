# Keil uVision project Automation.uvprojx, settings and files
target Automation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Automation
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\C&H
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group BIOS
    ../C&H/: BIOS.c
  group DEVICE
    ../C&H/: SyringePump.c Rotate_Servo.c Fingers.c Air_Charge.c Air_Bleed.c SolenoidValve.c Common.c
  group MODBUS
    ../C&H/Modbus/: mb.c MODBUS-Port-STM32.C
    ../C&H/Modbus/rtu/: mbcrc.c mbrtu.c
    ../C&H/Modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group APP
    ../C&H/: Automation.c
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS:Keil RTX 4.81.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
